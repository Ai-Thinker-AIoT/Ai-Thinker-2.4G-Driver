# Keil uVision project AI8051U-SI24R1.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8051U-8Bit Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x7FFF) IROM(0-0xFFFF) CLOCK(35000000)
  output: AI8051U-SI24R1 +hex
  c flags: SizeSpeed=1
  c include: .\Source;.\Toolchain\INC
  group User
    ./Source/: main.c SI24R1.c
  group SI24R1
    ./Source/: SI24R1.h XSFR_STC8051U_8Bit.H
