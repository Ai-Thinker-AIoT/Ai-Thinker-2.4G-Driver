# Keil uVision project CI24R1.uvproj, settings and files
target CI24R1 (MCS-51)
  device: STC15W408AS STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: CI24R1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\FWLib;..\CI24R1
  group USER
    ./: main.c
  group CI24R1
    ../CI24R1/: CI24R1.c
  group FWLib
    ../FWLib/: delay.c
  group README
    ../: README.txt
