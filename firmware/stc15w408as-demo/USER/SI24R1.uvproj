# Keil uVision project SI24R1.uvproj, settings and files
target SI24R1 (MCS-51)
  device: STC15W408AS STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: SI24R1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\FWLib;..\SI24R1
  group USER
    ./: main.c
  group SI24R1
    ../SI24R1/: SI24R1.c SI24R1.h
  group FWLib
    ../FWLib/: delay.c delay.h config.h typedef.h
  group README
    ../: README.txt
