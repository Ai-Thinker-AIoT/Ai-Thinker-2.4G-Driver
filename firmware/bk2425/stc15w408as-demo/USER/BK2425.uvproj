# Keil uVision project BK2425.uvproj, settings and files
target BK2425 (MCS-51)
  device: STC15W408AS STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: BK2425 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\FWLib;..\BK2425
  group USER
    ./: main.c
  group BK2425
    ../BK2425/: BK2425.c BK2425.h
  group FWLib
    ../FWLib/: delay.c delay.h config.h typedef.h
  group README
    ../: README.txt
